FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += "file://0001-bno055-dts.patch"
